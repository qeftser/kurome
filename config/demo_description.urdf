Commit message: tuning

File: config/demo_description.urdf (robot description, URDF)
Before this commit: robot bender, 7 links, 6 joints
Joints:
- joint lidar_joint: origin xyz=0 0 0.12 rpy=0 0 0 -> xyz=0 0 0.36 rpy=0 0 0
